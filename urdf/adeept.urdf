Commit message: Implemented differential drive for the robot

File: urdf/adeept.urdf (robot description, URDF)
Before this commit: robot adeept_awr, 7 links, 6 joints
Links:
- link chassis: mass 0.500 -> 0.100
